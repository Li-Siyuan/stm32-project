# Keil uVision project BH-F103.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BH-F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\FATFS;..\User\mp3;..\User\ad9834;..\User\ad5667
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: stm32f10x.h core_cm3.h core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: include.h main.c stm32f10x_conf.h stm32f10x_it.h stm32f10x_it.c nvic.h nvic.c gpio.c systick.c led.c key.c key_exti.c beep.c smg.c bsp_mcooutput.c bsp_clkconfig.c i2c_hard.c i2c_moni.c eeprom_i2cmoni.c dma_m2m.c dma_dst_uart.c dma_src_uart.c usart.c UartMoni.c spi.c flash_spi.c TIM_Base.c general_tim.c advance_tim.c dht11.c nrf24l01.c unpack.c sd.c adc.c dac.c tempad.c iwdg.c wwdg.c pvd.c pwr.c rtc.c date.c calendar.c
  group DOC
    ../Doc/: readme.txt
  group OLED|LCD
    ../User/: lcd_driver.c gui.c codetab.c picture.c oled_i2c.c oled_SSD1306_GT20L16.c oled_SSD1306_iic_8080.c asciicode.h touch.c st7735s_lcd.c st7735s_gui.c ASCII.c oled_iic.c ili9341.c fonts.c malloc.c bmp.c
  group mpu6050|DMP
    ../User/: dmp_exti.c inv_mpu_dmp_motion_driver.c inv_mpu.c mpu_dmp_useapi.c mpu6050_i2cmoni.c
  group CAMERAL
    ../User/: ov7725.c sccb.c ov7725_eagle.c
  group MP3
    ../User/mp3/: hc4052.c mp3player.c vs10xx.c
    ../User/: vs1053.c
  group FATFS
    ../User/FATFS/: cc936.c diskio.c ff.c myFatApp.c
  group ad9834
    ../User/ad9834/: ad9834.c ad9834.h
  group ad5667
    ../User/ad5667/: ad5667.c ad5667.h
